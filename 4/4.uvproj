# Keil uVision project 4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c run_lcd.c run_lcd.h button.c button.h clock_show.c clock_show.h delay.c delay.h useful.c useful.h
