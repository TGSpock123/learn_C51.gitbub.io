# Keil uVision project 3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c useful.h useful.c clock_show.h clock_show.c button.c button.h delay.c delay.h
